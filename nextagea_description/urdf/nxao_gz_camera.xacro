Commit message: PR fixes

File: nextagea_description/urdf/nxao_gz_camera.xacro (robot description, xacro)
@@ -24,5 +24,5 @@
 					<cylinder length="0.01" radius="0.015" />
 				</geometry>
-				<material name="blue" />
+				<material name="Blue" />
 			</visual>
 			<inertial>
